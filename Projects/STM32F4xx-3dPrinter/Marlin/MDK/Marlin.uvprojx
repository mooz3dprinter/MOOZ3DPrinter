# Keil uVision project Marlin.uvprojx, settings and files
target Project-Marlin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Marlin +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o app.bin Marlin/Marlin.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM_3DPRINT,MARLIN,__USE_C99_MATH,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\Drivers\BSP\STM32F4xx-3dPrinter;..\..\..\..\Drivers\BSP\MotorControl;..\..\..\..\Drivers\BSP\Components\l6474;..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\Middlewares\Third_Party\Marlin;..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\Drivers\USB;..\..\..\..\Drivers\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Drivers\USB\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Drivers\USB\STM32_USB_OTG_Driver\inc;..\..\..\..\Drivers\HMI;..\..\..\..\Middlewares\Third_Party\SeggerRTT;..\..\..\..\Drivers\W25QXX;..\..\..\..\Drivers\FM24Cl64
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Src/: clock_f4.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    ../../../../../Marlin4STM32_IAR/Marlin4St/stm32_cube/Projects/STM32F4xx-3dPrinter/Marlin/: readme.txt
  group BSP
    ../../../../Drivers/BSP/Components/l6474/: l6474.c
    ../../../../Drivers/BSP/MotorControl/: motorcontrol.c
    ../../../../Drivers/BSP/STM32F4xx-3dPrinter/: stm32f4xx_3dprinter_adc.c stm32f4xx_3dprinter_misc.c stm32f4xx_3dprinter_motor.c stm32f4xx_3dprinter_sd.c stm32f4xx_3dprinter_uart.c stm32f4xx_3dprinter_wifi.c spi.c
  group CMSIS
    ./: startup_stm32f401xe.s startup_stm32f40xx.s
    ../Src/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group FatFs
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c usbh_diskio.c
    ../../../../Middlewares/Third_Party/FatFs/src/option/: cc936.c
  group Marlin
    ../../../../Middlewares/Third_Party/Marlin/: BlinkM.cpp cardreader.cpp ConfigurationStore.cpp digipot_mcp4451.cpp Marlin_main.cpp MarlinSerial.cpp motion_control.cpp planner.cpp qr_solve.cpp Sd2Card.cpp SdBaseFile.cpp SdFatUtil.cpp SdFile.cpp SdVolume.cpp Servo.cpp stepper.cpp temperature.cpp ultralcd.cpp vector_3.cpp watchdog.cpp
  group STM32_USB_HOST_Library
    ../../../../Drivers/USB/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ../../../../Drivers/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group STM32_USB_OTG_Driver
    ../../../../Drivers/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32_USB_App
    ../../../../Drivers/USB/: usb_bsp.c usbh_usr.c
  group HMI
    ../../../../Drivers/HMI/: hmi.cpp hmi.h hmi_drv.cpp hmi_drv.h RingBuffer.cpp RingBuffer.h
  group W25QXX
    ../../../../Drivers/W25QXX/: w25qxx.c
